# Keil uVision project AnchorFOC.uvprojx, settings and files
target AnchorFOC (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: GD32F303CB GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AnchorFOC +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: .\GD32F30x_LIB\CMSIS\GD\GD32F30x\Include;.\GD32F30x_LIB\GD32F30x_standard_peripheral\Include;.\GD32F30x_LIB\CMSIS;.\Utilities;.;.\bsp;.\motor;.\components
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Components
    ./components/: fifo.c
  group Application
    ./app/: main.c sys_malloc.c usr_config.c
    ./: gd32f30x_it.c
  group Startup
    ./GD32F30x_LIB/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
    ./GD32F30x_LIB/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group GD32F30x_LIB
    ./GD32F30x_LIB/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group BSP
    ./bsp/: bsp_gpio.c bsp_usart.c bsp_timer.c bsp_adc.c bsp_mt6816.c bsp_systick.c
  group Motor
    ./motor/: calib.c trajectory.c control.c motor.c svpwm.c flag_storage.c
